<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hurdle_1</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>value</key><value>(samp_rate/(2*symbol_rate)*10**(-EbNo_dB/10.0))**0.5</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk</value></param>
<param><key>const_points</key><value>[-1-1j, -1+1j, 1+1j, 1-1j]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0, 1, 3, 2]</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11*4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samps_per_sym</value></param>
<param><key>value</key><value>samp_rate/symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>EbNo_dB</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>iq_filename</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>rx_packet_filename</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>symbols_out.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>200</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1+timing_offset_ppm/1e6</value></param>
<param><key>freq_offset</key><value>frequency_offset_hz/samp_rate</value></param>
<param><key>noise_voltage</key><value>noise_voltage</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency_offset_hz</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
</block>
<block>
<key>hurdle1_random_packet_source</key>
<param><key>id</key><value>hurdle1_random_packet_source_0</value></param>
<param><key>max_padding</key><value>4095</value></param>
<param><key>min_padding</key><value>2050</value></param>
<param><key>num_bits</key><value>100000</value></param>
<param><key>preamble</key><value>0x99999999</value></param>
<param><key>sync</key><value>0x1ACFFC1D</value></param>
<param><key>truth_name</key><value>truth_filename</value></param>
</block>
<block>
<key>hurdle1_tag_delay</key>
<param><key>id</key><value>hurdle1_tag_delay_0</value></param>
<param><key>delay</key><value>int(22*samps_per_sym)</value></param>
</block>
<block>
<key>hurdle1_tcp_server_sink</key>
<param><key>id</key><value>hurdle1_tcp_server_sink_0</value></param>
<param><key>host</key><value>host</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>port</key><value>iq_port</value></param>
</block>
<block>
<key>hurdle1_tcp_server_source</key>
<param><key>id</key><value>hurdle1_tcp_server_source_0</value></param>
<param><key>host</key><value>host</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>port</key><value>packet_port</value></param>
</block>
<block>
<key>hurdle1_traffic_parser</key>
<param><key>id</key><value>hurdle1_traffic_parser_0</value></param>
<param><key>len_tag_name</key><value>pkt_len</value></param>
<param><key>zero_pad_tag_name</key><value>zero_pad</value></param>
</block>
<block>
<key>hurdle1_zero_pad</key>
<param><key>id</key><value>hurdle1_zero_pad_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>zero_pad_tag_name</key><value>zero_pad</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>iq.dat</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>iq_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9094</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>mod</value></param>
<param><key>constellation</key><value>qpsk</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>0.7</value></param>
<param><key>samples_per_symbol</key><value>samps_per_sym</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packet_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>9095</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>200</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_packet_filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rx_packets.bin</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>timing_offset_ppm</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>truth_filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>truth.bin</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_packet_filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>out_packets.bin</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>hurdle1_tcp_server_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hurdle1_random_packet_source_0</source_block_id><sink_block_id>hurdle1_traffic_parser_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hurdle1_tag_delay_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hurdle1_tag_delay_0</source_block_id><sink_block_id>hurdle1_zero_pad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hurdle1_tcp_server_source_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hurdle1_traffic_parser_0</source_block_id><sink_block_id>mod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hurdle1_zero_pad_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mod</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mod</source_block_id><sink_block_id>hurdle1_tag_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
